# Copyright (C) 2013 Eric Bénard - Eukréa Electromatique

PACKAGECONFIG_append = " accessibility examples linuxfb"
