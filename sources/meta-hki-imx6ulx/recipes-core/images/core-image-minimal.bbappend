IMAGE_INSTALL += "imx-kobs \
    tslib-calibrate \
    tslib-conf \
    tslib-tests \
    bzip2 \
    gzip \
    mtd-utils \
    mtd-utils-ubifs \
    rpm \
    udev-extraconf \
    udev-rules-imx \
    wpa-supplicant \
    wpa-supplicant-cli \
    wpa-supplicant-passphrase"

